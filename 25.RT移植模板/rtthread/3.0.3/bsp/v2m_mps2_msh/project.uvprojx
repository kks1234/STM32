# Keil uVision project project.uvprojx, settings and files
target V2M-MPS2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: IROM(0x00000000,0x400000) IRAM(0x20000000,0x400000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: __USE_FPGA
  c include: C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.6.0\CMSIS\Driver;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.2.0\CMSIS\Driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\project.sct
  link misc: --keep *.o(.rti_fn.*)
  group Source Files
    ./: drv_uart.c main.c
software components: CMSIS:CORE 5.0.2, Board Support:Common 2.0.0, Device:Startup 1.0.0, RTOS:device drivers 3.0.3, RTOS:kernel 3.0.3, RTOS:shell 3.0.3
