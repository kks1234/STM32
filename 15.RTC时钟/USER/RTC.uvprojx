# Keil uVision project RTC.uvprojx, settings and files
target RTC (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTC +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE;..\STM32F10X_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c
  group USER
    ./: main.c stm32f10x_it.c
    ../CORE/: startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10X_FWLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_pwr.c
    ./: system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/: lcd.c led.c rtc.c
