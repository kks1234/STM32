# Keil uVision project MODBUS.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MODBUS +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\modbus;..\TIM;..\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c startup_stm32f10x_hd.s
  group USART
    ../USART/: usart.c
  group TIM
    ../TIM/: tim.c
  group modbus
    ../modbus/: ModbusCRC.c modbus.c
